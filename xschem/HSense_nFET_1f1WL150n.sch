v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 290 230 0 0 {name=p5 lab=Vgateh}
C {devices/iopin.sym} 290 210 0 0 {name=p7 lab=VDh}
C {nFET_1f1WL150n.sym} 140 220 0 0 {name=x1}
C {nFET_1f1WL150n.sym} 150 40 0 0 {name=x2}
C {nFET_1f1WL150n.sym} 150 130 0 0 {name=x3}
C {devices/iopin.sym} 300 50 0 0 {name=p1 lab=Vgateh}
C {devices/iopin.sym} 300 30 0 0 {name=p3 lab=VDh}
C {devices/iopin.sym} 300 120 0 0 {name=p9 lab=VDs}
C {devices/iopin.sym} 300 140 0 0 {name=p10 lab=Vgates}
